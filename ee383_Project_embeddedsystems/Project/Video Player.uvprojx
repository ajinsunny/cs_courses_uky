# Keil uVision project Video Player.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.4.1.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: Video Player
  c flags: Optim=1 wLevel=2
  c include: ..\Project;.\driverlib;.\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ../stellaris-launchpad-video-player-master/: LM4F_startup.c loop.h main.c sd.c SD.h TFT.c TFT.h
    ./: lm4f120h5qr.h gpio.h startup.s
